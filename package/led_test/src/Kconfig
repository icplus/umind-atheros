## package/led_test/src/Kconfig
```kconfig
config EXAMPLE
　　tristate "led test model"
　　default n
　　help
　　　This is a led test model, for debugging kernel model.
　　　If unsure, say N.
```
